# Keil uVision project BJCar.uvprojx, settings and files
target BJCar (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pwm +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\UserProject;..\STM32F10x_Lib\inc;..\Core;..\Hdr\delay;..\Hdr\key;..\Hdr\led;..\Hdr\timer;..\Hdr\sys;..\Hdr\pwm;..\HDR\usart;..\HDR\Control;..\HDR\MPU6050;..\HDR\MPU6050\eMPL;..\HDR\PID;..\HDR\EXTI;..\HDR\新建文件夹;..\UserProject;..\HDR\LCD;..\HDR\spi
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c GUI.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HDR
    ../Hdr/delay/: delay.c
    ../Hdr/key/: key.c
    ../Hdr/led/: led.c
    ../Hdr/sys/: sys.c
    ../Hdr/pwm/: pwm.c
    ../HDR/usart/: usart.c
    ../HDR/timer/: timer.c
    ../HDR/Control/: control.c
    ../HDR/PID/: pid.c
    ../HDR/MPU6050/: mpu6050.c mpuiic.c
    ../HDR/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HDR/EXTI/: exti.c
    ../HDR/新建文件夹/: usart2.c
    ../HDR/LCD/: lcd.c
